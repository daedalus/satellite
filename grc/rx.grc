<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code</value></param>
<param><key>value</key><value>barker_code_two_dim if (const_choice == "qpsk") else barker_code_one_dim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_one_dim</value></param>
<param><key>value</key><value>sqrt(2)*numpy.real([-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_two_dim</value></param>
<param><key>value</key><value>[-1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j,  1.0000 + 1.0000j, -1.0000 - 1.0000j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_len</value></param>
<param><key>value</key><value>13</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codeword_len</value></param>
<param><key>value</key><value>18444</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_choice</value></param>
<param><key>value</key><value>"qpsk"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_order</value></param>
<param><key>value</key><value>pow(2,constellation.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation</value></param>
<param><key>value</key><value>qpsk_const if (const_choice=="qpsk") else bpsk_const</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dataword_len</value></param>
<param><key>value</key><value>6144</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec_factor</value></param>
<param><key>value</key><value>ceil(dsp_rate/target_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dsp_rate</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>est_cfo_hz</value></param>
<param><key>block_id</key><value>tuning_control</value></param>
<param><key>function_args</key><value>self.mods_ffw_coarse_freq_rec_0.mods_runtime_cfo_ctrl_0.get_cfo_estimate(), self.mods_ffw_coarse_freq_rec_0.mods_runtime_cfo_ctrl_0.get_rf_center_freq(), [self.rtlsdr_source_0.get_center_freq() if hasattr(self, 'rtlsdr_source_0') else freq]</value></param>
<param><key>function_name</key><value>update_nco_freq</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>poll_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>even_dec_factor</value></param>
<param><key>value</key><value>dec_factor if (dec_factor % 1 == 1) else (dec_factor+1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_barker_rep</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_codewords</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_rrc_taps</value></param>
<param><key>value</key><value>rrc_delay * int(sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>codeword_len*n_codewords/int(numpy.log2(const_order))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pmf_peak_threshold</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_size</value></param>
<param><key>value</key><value>len(preamble_syms)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_syms</value></param>
<param><key>value</key><value>numpy.matlib.repmat(barker_code, 1, n_barker_rep)[0]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_delay</value></param>
<param><key>value</key><value>int(round(-44*excess_bw + 33))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, excess_bw, n_rrc_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>dsp_rate/even_dec_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>samp_rate/sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_samp_rate</value></param>
<param><key>value</key><value>sps*(200e3/(1 + excess_bw))</value></param>
</block>
<block>
<key>variable_tuning_control_def</key>
<param><key>id</key><value>tuning_control</value></param>
<param><key>freq_step</key><value>1</value></param>
<param><key>max_freq</key><value>0</value></param>
<param><key>min_freq</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rx_addr</value></param>
<param><key>value</key><value>"192.168.10.2"</value></param>
</block>
<block>
<key>variable_rx_logger</key>
<param><key>id</key><value>variable_rx_logger_0</value></param>
<param><key>cfo_rec</key><value>self.mods_ffw_coarse_freq_rec_0</value></param>
<param><key>decoder</key><value>self.framers_gr_hdlc_deframer_b_0</value></param>
<param><key>frame_synchronizer</key><value>self.frame_synchronizer_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>ber_log_period</key><value>10</value></param>
<param><key>cfo_log_period</key><value>10</value></param>
<param><key>frame_sync_log_period</key><value>10</value></param>
<param><key>snr_log_period</key><value>1</value></param>
<param><key>snr_meter</key><value>self.mods_mer_measurement_pre_frame_sync</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0 if file_input is ""  else 1</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>comment</key><value>Automatic Gain Control</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>file_input</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_1</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>4321</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>comment</key><value>Output single-bit char</value></param>
<param><key>k</key><value>constellation.bits_per_symbol()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0</value></param>
<param><key>comment</key><value>QPSK/BPSK Decoder</value></param>
<param><key>constellation</key><value>constellation.base()</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>comment</key><value>Carrier Phase Recovery</value></param>
<param><key>w</key><value>2*pi/loopbw</value></param>
<param><key>order</key><value>2**constellation.bits_per_symbol()</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0_0</value></param>
<param><key>map</key><value>[1,- 1]</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>comment</key><value>Symbol Timing Recovery</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>2*pi/50</value></param>
<param><key>max_dev</key><value>pi/8</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>Carrier Freq. Recovery FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_input</value></param>
<param><key>comment</key><value>Disable RTL and use 
Rx samples from file.</value></param>
<param><key>label</key><value>File input</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fllbw</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.002</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_sync_verbosity</value></param>
<param><key>label</key><value>Frame Sync Verbosity</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>frame_synchronizer</key>
<param><key>id</key><value>frame_synchronizer_0</value></param>
<param><key>comment</key><value>Frame Synchronization</value></param>
<param><key>M</key><value>int(const_order)</value></param>
<param><key>fw_preamble</key><value>1</value></param>
<param><key>payload_size</key><value>payload_size</value></param>
<param><key>pmf_peak_threshold</key><value>pmf_peak_threshold</value></param>
<param><key>fix_phase</key><value>1</value></param>
<param><key>preamble_size</key><value>preamble_size</value></param>
<param><key>preamble_syms</key><value>preamble_syms</value></param>
<param><key>equalize</key><value>1</value></param>
<param><key>verbosity</key><value>frame_sync_verbosity</value></param>
</block>
<block>
<key>framers_gr_hdlc_deframer_b</key>
<param><key>id</key><value>framers_gr_hdlc_deframer_b_0</value></param>
<param><key>comment</key><value>Carrier Freq. Recovery</value></param>
<param><key>dlci</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_rec_alpha</value></param>
<param><key>label</key><value>Carrier Freq. Recovery Averaging Alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import *</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy </value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import numpy.matlib</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>loopbw</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>800</value></param>
</block>
<block>
<key>mods_da_carrier_phase_rec</key>
<param><key>id</key><value>mods_da_carrier_phase_rec_0_0</value></param>
<param><key>comment</key><value>Data-aided Phase Recovery</value></param>
<param><key>M</key><value>int(const_order)</value></param>
<param><key>damp_factor</key><value>1/sqrt(2)</value></param>
<param><key>noise_bw</key><value>0.001</value></param>
<param><key>data_aided</key><value>True</value></param>
<param><key>preamble_syms</key><value>(1/sqrt(2))*preamble_syms</value></param>
<param><key>reset_per_frame</key><value>True</value></param>
</block>
<block>
<key>mods_ffw_coarse_freq_rec</key>
<param><key>id</key><value>mods_ffw_coarse_freq_rec_0</value></param>
<param><key>abs_cfo_threshold</key><value>0.95*(samp_rate/8)</value></param>
<param><key>alpha</key><value>freq_rec_alpha</value></param>
<param><key>comment</key><value>Carrier Freq. Recovery</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>rf_center_freq</key><value>freq</value></param>
</block>
<block>
<key>mods_fifo_async_sink</key>
<param><key>id</key><value>mods_fifo_async_sink_0</value></param>
<param><key>fifo_file</key><value>/tmp/async_rx</value></param>
</block>
<block>
<key>mods_mer_measurement</key>
<param><key>id</key><value>mods_mer_measurement_pre_frame_sync</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>M</key><value>int(const_order)</value></param>
</block>
<block>
<key>mods_nco_cc</key>
<param><key>id</key><value>mods_nco_cc_0</value></param>
<param><key>comment</key><value>Uses CFO estimation 
from function probe</value></param>
<param><key>phase_inc</key><value>(2*pi*(est_cfo_hz/samp_rate))</value></param>
<param><key>n_steps</key><value>100</value></param>
</block>
<block>
<key>mods_turbo_decoder</key>
<param><key>id</key><value>mods_turbo_decoder_0</value></param>
<param><key>N</key><value>codeword_len</value></param>
<param><key>K</key><value>dataword_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>poll_rate</value></param>
<param><key>label</key><value>CFO Poll Rate</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>comment</key><value>Send to Sync Chain</value></param>
<param><key>stream_id</key><value>rx_norm_seq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0_0</value></param>
<param><key>stream_id</key><value>rx_seq</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5</value></param>
<param><key>comment</key><value>Send to Frame Synchronizer</value></param>
<param><key>stream_id</key><value>sym_pfbsync_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_6</value></param>
<param><key>comment</key><value>Send to Constellation Receiver</value></param>
<param><key>stream_id</key><value>payload_sym</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>rx_seq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>rx_norm_seq</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>sym_pfbsync_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5</value></param>
<param><key>comment</key><value>Payload Symbols</value></param>
<param><key>stream_id</key><value>payload_sym</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>virtual_sink_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>digital_map_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>mods_mer_measurement_pre_frame_sync</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>virtual_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>framers_gr_hdlc_deframer_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0_0</source_block_id><sink_block_id>mods_turbo_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>mods_da_carrier_phase_rec_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>frame_synchronizer_0</source_block_id><sink_block_id>mods_da_carrier_phase_rec_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>framers_gr_hdlc_deframer_b_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>framers_gr_hdlc_deframer_b_0</source_block_id><sink_block_id>mods_fifo_async_sink_0</sink_block_id><source_key>pdu</source_key><sink_key>async_pdu</sink_key></connection>
<connection><source_block_id>mods_da_carrier_phase_rec_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_da_carrier_phase_rec_0_0</source_block_id><sink_block_id>virtual_sink_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_ffw_coarse_freq_rec_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_mer_measurement_pre_frame_sync</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_nco_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mods_turbo_decoder_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_rms_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>mods_ffw_coarse_freq_rec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>mods_nco_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>frame_synchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>digital_constellation_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
